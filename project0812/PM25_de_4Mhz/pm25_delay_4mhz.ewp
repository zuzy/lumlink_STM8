# IAR project pm25_delay_4mhz.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $TOOLKIT_DIR$\inc\; ..\; code\; 
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: pm25_delay_4mhz.bin
  ILINK.IlinkOutputFile: pm25_delay_4mhz.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    code/: adc.c convert.c dht11.c exti_KEY.c gpio.c lcd1602.c main.c pm2_5.c time.c uart.c
