<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\..\USER\clk_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\stm8s_interruput.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\uart.c</name>
    </file>
  </group>
</project>


