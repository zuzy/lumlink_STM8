<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\code\adc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\code\lcd1602.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\code\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\code\time.c</name>
  </file>
</project>


