# IAR project pwm_tim1_ch1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\USER; $TOOLKIT_DIR$\inc\; 
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: pwm_tim1_ch1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: clk_conf.c main.c pwm.c
