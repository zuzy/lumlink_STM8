<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pm25_delay_4mhz.ewp</path>
  </project>
  <batchBuild/>
</workspace>


